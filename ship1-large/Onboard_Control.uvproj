# Keil uVision project Onboard_Control.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 工程模板 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\user;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\APP\LED;.\APP\蜂鸣器;.\APP\SysTick;.\APP\按键;.\APP\232串口;.\APP\外部中断;.\APP\数码管;.\APP\定时器;.\APP\PWM;.\APP\Switch;.\APP\Control;.\APP\DHT11;.\APP\delay;.\APP\GPS;.\APP\timer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c stm32f10x_it.c public.c
  group cmsis
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group startup
    ./startup/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_exti.c stm32f10x_tim.c
  group APP
    ./APP/LED/: led.c
    ./APP/蜂鸣器/: beep.c
    ./APP/SysTick/: systick.c
    ./APP/按键/: key.c
    ./APP/232串口/: usart.c
    ./APP/外部中断/: exti.c
    ./APP/数码管/: smg.c
    ./APP/定时器/: time.c
    ./APP/PWM/: pwm.c
    ./APP/Switch/: switch.c
    ./APP/Control/: control.c
    ./APP/DHT11/: DHT11.c
    ./APP/GPS/: gps.c
    ./APP/timer/: timer7.c
